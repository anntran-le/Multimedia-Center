# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c IRQ.c GLCD_SPI_LPC1700.c LED.c ADC.c KBD.c adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c game.c
  group Pictures
    ./: avocado.c toast.c
  group Documentation
    ./: Abstract.txt
